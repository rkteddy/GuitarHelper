# Keil uVision project GuitarHelper.uvprojx, settings and files
target GuitarTunner (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 合
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\User;..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../User/: adc.c Lcd.c main.c stm32f10x_it.c touch.c
  group source
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group core
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
